# IAR project FCU_B.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x100
  General.SCCStackSize: 0x100
  General.SCRStackSize: 32
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm128a.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  ICCAVR.CCDefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\lnk0t.xcl
  XLINK.XExtraOptions: -y(CODE); -Ointel-extended,(DATA)=$EXE_DIR$\$PROJ_FNAME$_data.hex; -Ointel-extended,(XDATA)=$EXE_DIR$\$PROJ_FNAME$_eeprom.hex
  group CODE
    ../code/: AvrAdc.c AvrAdc.h AvrEEp.c AvrEEp.h AvrUART.c AvrUART.h CLModbus.c CLModbus.h CRC.c CRC.h DIDrv.c DIDrv.h FC.c FC.h includes.h main.c main.h PID.c PWM.c PWM.h StdMd.c StdMd.h
