<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\FCU_B.ewp</path>
  </project>
  <batchBuild/>
</workspace>


