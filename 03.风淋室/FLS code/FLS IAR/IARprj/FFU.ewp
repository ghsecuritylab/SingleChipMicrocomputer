# IAR project FFU.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm16a.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\lnk0t.xcl
  XLINK.XExtraOptions: -y(CODE); -Ointel-extended,(DATA)=$EXE_DIR$\$PROJ_FNAME$_data.hex; -Ointel-extended,(XDATA)=$EXE_DIR$\$PROJ_FNAME$_eeprom.hex
  group CODE
    ../../: _74LS165.c AVReeprom.c AvrUART.c CLModbus.c CRC.c FLSKeyTestCtrl.c FLSMain.c FLSshow.c FLSStatus.c FLSVoice.c StdMd.c
  group CommHeader
    ../../: _74LS165.h AVReeprom.h AvrUART.h CLModbus.h CRC.h FLSKeyTestCtrl.h flsmain.h FLSshow.h flsstatus.h FLSVoice.h includes.h StdMd.h
